# IAR project Backup of proj01_LED.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCIncludePath2: App\Inc; ..\..\Chip\Inc; ..\..\Chip\Inc\IAR; ..\..\Chip\Inc\kinetis; ..\..\Lib\CMSIS\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: proj01_LED.srec
  ILINK.IlinkOutputFile: proj01_LED.out
  ILINK.IlinkIcfFile: ..\..\config files\vcan_RAM_K60N512.icf
  ILINK.IlinkAdditionalLibs: ..\..\Lib\CMSIS\iar_cortexM4l_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    App/Inc/: include.h MK60_conf.h MK60_it.h PORT_cfg.h
    App/: main.c MK60_conf.c MK60_it.c
  group Chip
    ../../Chip/src/: misc.c MK60_DWT.c MK60_flash.c MK60_gpio.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_SysTick.c MK60_uart.c MK60_wdog.c vectors.c
    ../../Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
